# Keil uVision project lab-3-keil.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab-3-keil
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group main
    ./src/: main.c uart_implementation.c timer_implementation.c systick_implementation.c gpio_implementation.c
    ./: startup_rvmdk.S
  group utils
    ../utils/: uartstdio.c
  group driverlib
    ../driverlib/: sysctl.c gpio.c systick.c uart.c timer.c interrupt.c cpu.c
