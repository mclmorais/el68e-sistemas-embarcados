<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Modelo_C_asm_IAR8.ewp</path>
    </project>
    <batchBuild />
</workspace>
